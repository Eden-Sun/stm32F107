# Keil uVision project Project.uvprojx, settings and files
target STM3210C_EVAL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210C_EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC,USE_STM3210C_EVAL,
  c misc: --C99
  c include: .\Inc;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\BSP\STM3210C_EVAL;.\Drivers\BSP\Components;.\Middlewares\Third_Party\LwIP\src\include\;.\Middlewares\Third_Party\LwIP\src\include\ipv4;.\Middlewares\Third_Party\LwIP\system;.\Utilities;.\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\Middlewares\Third_Party\FatFs\src;.\Middlewares\Third_Party\FatFs\src\drivers
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group StartUp
    ./: startup_stm32f107xc.s
  group src
    ./Src/: app_ethernet.c ethernetif.c main.c stm32f1xx_it.c tcp_echoserver.c usbd_conf.c usbd_desc.c usbd_storage.c udp_echoclient.c tftpserver.c tftputils.c system_stm32f1xx.c
  group Docs
    ../: readme.txt
  group Drivers/BSP/STM3210C_EVAL
    ./Drivers/BSP/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_sd.c
  group Drivers/STM32F1xx_HAL_Driver
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Middlewares/LwIP/Api
    ./Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Core
    ./Middlewares/Third_Party/LwIP/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ./Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/LwIP/Netif
    ./Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Middlewares/STM32/Class/MSC
    ./Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/STM32/Core
    ./Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/fatFS/Core
    ./Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/fatFS/Driver
    ./Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/fatFS/Options
    ./Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
software components: CMSIS:CORE 4.1.0
